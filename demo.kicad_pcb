# Repository ram-kumar-shrestha/minor-project

## KiCad design demo.kicad_pcb

Parts:
A1: Arduino_UNO_R3
D1, D2, D3, D4: D; D_5KP_P10.16mm_Horizontal
J1: DHT; PinHeader_1x03_P2.54mm_Vertical
J2: GAS; PinHeader_1x04_P2.54mm_Vertical
J3: SOIL; PinHeader_1x04_P2.54mm_Vertical
J4, J5, J7, J8: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
J6: LDR; PinHeader_1x03_P2.54mm_Vertical
J9: Jack-DC; BarrelJack_Horizontal
J10: esp1*4; PinHeader_1x04_P2.54mm_Vertical
J11: esp2*4; PinHeader_1x04_P2.54mm_Vertical
J12: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
K1: PUMP_RELAY; Relay_SPDT_SANYOU_SRD_Series_Form_C
K2: LIGHT_RELAY; Relay_SPDT_SANYOU_SRD_Series_Form_C
K3: PELTIER_RELAY; Relay_SPDT_SANYOU_SRD_Series_Form_C
K4: FAN_RELAY; Relay_SPDT_SANYOU_SRD_Series_Form_C
Q1, Q2, Q3, Q4: BC547; TO-92L_Wide
R1, R2, R3, R4, R5, R6: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal

Connections:
+3V3: A1.4 (3V3), J10.2, J10.3, J10.4
+5V: A1.5 (+5V), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.1, J2.4, J3.1, J6.1, J9.1, J12.1, K1.5, K2.5, K3.5, K4.5
/0: A1.15 (D0/RX)
/1: A1.16 (D1/TX)
/2: A1.17 (D2)
/3: A1.18 (D3), J1.2
/4: A1.19 (D4)
/5: A1.20 (D5)
/6: A1.21 (D6), J10.1
/7: A1.22 (D7), R5.2
/8: A1.23 (D8)
/9: A1.24 (D9)
/10: A1.25 (D10), R4.2
/11: A1.26 (D11), R2.2
/12: A1.27 (D12), R3.2
/13: A1.28 (D13), R1.2
/A0: A1.9 (A0)
/A1: A1.10 (A1)
/A2: A1.11 (A2), J6.2
/A3: A1.12 (A3), J3.3
/A4: A1.13 (A4/SDA), J2.1
/A5: A1.14 (A5/SCL)
/AREF: A1.30 (AREF)
/IOREF: A1.2 (IOREF)
/Reset: A1.3 (RESET)
/Vin: A1.8 (VIN)
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND), J1.3, J2.3, J3.4, J6.3, J9.2, J11.1, J12.2, Q1.3 (E), Q2.3 (E), Q3.3 (E), Q4.3 (E), R6.1
unnamed: D1.2 (A), K1.2, Q1.1 (C)
unnamed: D2.2 (A), K2.2, Q2.1 (C)
unnamed: D3.2 (A), K3.2, Q3.1 (C)
unnamed: D4.2 (A), K4.2, Q4.1 (C)
unnamed: J4.1, K1.4
unnamed: J4.2, K1.1
unnamed: J4.3, K1.3
unnamed: J5.1, K2.4
unnamed: J5.2, K2.1
unnamed: J5.3, K2.3
unnamed: J7.1, K3.4
unnamed: J7.2, K3.1
unnamed: J7.3, K3.3
unnamed: J8.1, K4.4
unnamed: J8.2, K4.1
unnamed: J8.3, K4.3
unnamed: J11.4, R5.1, R6.2
unnamed: Q1.2 (B), R1.1
unnamed: Q2.2 (B), R2.1
unnamed: Q3.2 (B), R3.1
unnamed: Q4.2 (B), R4.1

Board: 2 copper layers, 31 parts (0 on the bottom side), 34 nets.

## Commit log

2021-02-02 Revised Version
